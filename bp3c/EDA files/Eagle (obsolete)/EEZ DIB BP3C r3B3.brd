# Repository eez-open/modular-psu (continued)

## EAGLE design dcm220/Eagle files/EEZ DIB DCM220 r2B8.brd (continued)

Schematic: EEZ DIB DCM220 r2B8.sch, sheet 3, Channel #1

Parts:
C45, C47, C51: 100n; C0603
C46: EEEFK1H470; CAPAE830X1050N
C48: 100p; C0805
C49: 4u7; C1206
C50, C52: 10u; C1210
C53, C57: 1u; C0805
C54: 220n; C0805
C55: 22u; C1206
C56, C63: 10n/200V; C1206
C58: N.C.; C0805
C59, C60: 22u; C1210
C61: EEEFK1V470P; CAPAE660X610N
C62: UVZ1E102MPD; ECAP5/10.5
C64: 470p; C0805
C65: 33n; C0805
C66: 10n; C0805
C67: 4n7; C0805
CH1: TEST_POINT-2; TP_1.1MM_2
D3, D4, D6: SKL16; SOD123
D5: N.C.; SOD123
D7: N.C.; SMA
GND: TEST-PIN_0.9MM
IC10: MC33272ADR2G; SOIC127P600X173-8N
IC11: LT3763EFE#PBF; LTC_05-08-1663-EB
IC12: MC33274ADR2G; SOIC127P600X175-14N
J2: 571-0500; DELTRON_571
J3: 571-0100; DELTRON_571
L2: 125CDMCCDS-330MC; 125CDMCC/DS
L3: HPI0630-3R3; COILCRAFT_HPI0630
LED1: WP42WUM/EGW; L-42WUM-1EGWT
Q1: BSP716NH6327XTSA1; SOT223
Q2, Q3: NTD5867NLT4G; TO229P990X239-3N
Q4: BSS205NH6327XTSA1; SOT103P240X110-3N
Q5: BSS84; SOT95P237X112-3N
R28, R35, R36: 10R; R0805
R29, R40, R42: 86K6; R0805
R30, R32: 20K; R0805
R31, R33, R47: 12K; R0805
R34: R012/2W; R_2512-4WIRE
R37: N.C.; R1206
R38: 2K2; R0805
R39: 30K; R0805
R41, R48: 3K3; R0805
R43, R44, R76: 47K; R0805
R45: 100K; R0805
R46: 3K6; R0805
R49: 120R; R0805
R50: 11K8; R0805
R51: 15K; R0805
X4: DS1024-2*5R0; SSW-105-02-T-D-RA
ZD2: MM3Z9V1T1G; SOD323-W
ZD3: SMAJ51A; DO214AA

Connections:
+3V3: C47.1, IC12.4 (V+), Q5.2 (S); also elsewhere on the board
+8V: C45.1, D5.A, IC10.8 (V+); also elsewhere on the board
-8V: C51.2, IC10.4 (V-); also elsewhere on the board
BG1: IC11.1 (BG), Q3.1 (G)
CC#1: IC12.7 (OUT); also elsewhere on the board
CC_LED#1: Q5.1 (G), R49.2; also elsewhere on the board
DC_OUT+: C46.+, C50.1, C52.1, IC11.6 (IVINN), IC11.7 (IVINP), Q2.2 (D), R28.1, R29.1; also elsewhere on the board
FB1: IC11.11 (FB), IC12.10 (+IN), R39.1, R46.2, R48.2
GND: C45.2, C46.-, C47.2, C49.2, C50.2, C51.1, C52.2, C53.2, C55.2, C57.2, C59.2, C60.2, C61.2 (-), C62.-, C63.2, C64.1, C66.1, CH1.GND, D7.A, GND.1, IC11.12 (GND), IC11.21 (SYNC), IC11.23 (GND), IC11.28 (GND), IC11.TP (GND_PAD), IC12.11 (V-), J3.1, J3.1.1, LED1.CC (C), Q3.3 (S), R30.1, R33.1, R37.1, R41.2, R42.1, R45.1, R46.1, R47.1, R51.1, R76.2, X4.1, X4.2, X4.3, X4.4, X4.5, X4.6, X4.7, X4.8, X4.9, X4.10, ZD3.A; also elsewhere on the board
INTVCC1: C55.1, D6.A, IC11.2 (INTVCC), R43.1, R44.2
ISET1: C48.1, IC10.7 (OUT), IC11.14 (CTRL1), R31.2
I_MON1: C64.2, R38.1; also elsewhere on the board
I_SET#1: R32.1; also elsewhere on the board
LOUT1: L2.2, R34.1
unnamed: Q4.3 (D), Q5.3 (D)
unnamed: R34.1S, R35.2
unnamed: IC11.20 (RT), R42.2
unnamed: LED1.RED (AR), R49.1
unnamed: C66.2, IC11.15 (SS)
unnamed: C67.1, R45.2
unnamed: C67.2, IC11.18 (VC)
unnamed: R34.2S, R36.2
unnamed: C58.2, R37.2
unnamed: IC11.9 (!FAULT), R44.1
unnamed: C54.1, D6.C, IC11.27 (BOOST)
unnamed: D4.C, Q1.1 (G), R29.2, ZD2.C
unnamed: LED1.GREEN (AG), Q4.2 (S)
unnamed: C49.1, D3.C, D5.C, IC11.3 (VIN)
unnamed: D3.A, D4.A, Q1.3 (S)
unnamed: IC11.19 (ISMON), R38.2
unnamed: IC12.5 (+IN), R50.1, R51.2
unnamed: IC12.6 (-IN), IC12.8 (OUT), IC12.9 (-IN)
unnamed: IC10.5 (+IN), R32.2, R33.2
unnamed: C48.2, IC10.6 (-IN), R30.2, R31.1
OE#1: IC11.4 (EV/UVLO), Q4.1 (G), R76.1; also elsewhere on the board
PE: C56.1, C63.1; also elsewhere on the board
PWM#1: IC11.22 (PWM), R43.2
Q1D: Q1.2 (D), Q1.4 (D), R28.2
SENSE1+: C65.1, IC11.17 (SENSE+), R35.1
SENSE1-: C65.2, IC11.16 (SENSE-), R36.1
SW1: C54.2, C58.1, D7.C, IC11.26 (SW), L2.1, Q2.3 (S), Q3.2 (D)
TG1: IC11.25 (TG), Q2.1 (G)
U_MON1: R40.1, R47.2; also elsewhere on the board
U_SET#1: R48.1; also elsewhere on the board
VOUT1+: C59.1, C60.1, C62.+, L3.1, R34.2, R39.2, R40.2, ZD2.A
VOUT_LC1+: C56.2, C57.1, C61.1 (+), CH1.TIP, J2.1, J2.1.1, L3.2, R41.1, ZD3.C
VREF1: C53.1, IC11.5 (VREF), IC11.10 (FBIN), IC11.13 (CTRL2), R50.2

Notes on the sheet:
Licensed under the TAPR Open Hardware License (www.tapr.org/OHL)
Repository: https://github.com/eez-open
More info at http://www.envox.hr/eez
Power channel #1
CC mode detection
DIB v1.0 power connector (Vout- only)
Op-amp's decoupling
OE and CC indications

Schematic: EEZ DIB DCM220 r2B8.sch, sheet 4, Channel #2

Parts:
C68: EEEFK1H470; CAPAE830X1050N
C69: 100p; C0805
C70: 4u7; C1206
C71, C72: 10u; C1210
C73, C77: 1u; C0805
C74: 220n; C0805
C75: 22u; C1206
C76, C83: 10n/200V; C1206
C78: N.C.; C0805
C79, C80: 22u; C1210
C81: EEEFK1V470P; CAPAE660X610N
C82: UVZ1E102MPD; ECAP5/10.5
C84: 470p; C0805
C85: 33n; C0805
C86: 10n; C0805
C87: 4n7; C0805
CH2: TEST_POINT-2; TP_1.1MM_2
D8, D9, D11: SKL16; SOD123
D10: N.C.; SOD123
D12: N.C.; SMA
IC10: MC33272ADR2G; SOIC127P600X173-8N
IC12: MC33274ADR2G; SOIC127P600X175-14N
IC13: LT3763EFE#PBF; LTC_05-08-1663-EB
J4: 571-0500; DELTRON_571
J5: 571-0100; DELTRON_571
L4: 125CDMCCDS-330MC; 125CDMCC/DS
L5: HPI0630-3R3; COILCRAFT_HPI0630
LED2: WP42WUM/EGW; L-42WUM-1EGWT
Q6: BSP716NH6327XTSA1; SOT223
Q7, Q8: NTD5867NLT4G; TO229P990X239-3N
Q9: BSS205NH6327XTSA1; SOT103P240X110-3N
Q10: BSS84; SOT95P237X112-3N
R52, R59, R60: 10R; R0805
R53, R64, R66: 86K6; R0805
R54, R56: 20K; R0805
R55, R57, R71: 12K; R0805
R58: R012/2W; R_2512-4WIRE
R61: N.C.; R1206
R62: 2K2; R0805
R63: 30K; R0805
R65, R72: 3K3; R0805
R67, R68, R77: 47K; R0805
R69: 100K; R0805
R70: 3K6; R0805
R73: 120R; R0805
R74: 11K8; R0805
R75: 15K; R0805
ZD4: MM3Z9V1T1G; SOD323-W
ZD5: SMAJ51A; DO214AA

Connections:
+3V3: Q10.2 (S); also elsewhere on the board
+8V: D10.A; also elsewhere on the board
BG2: IC13.1 (BG), Q8.1 (G)
CC#2: IC12.1 (OUT); also elsewhere on the board
CC_LED#2: Q10.1 (G), R73.2; also elsewhere on the board
DC_OUT+: C68.+, C71.1, C72.1, IC13.6 (IVINN), IC13.7 (IVINP), Q7.2 (D), R52.1, R53.1; also elsewhere on the board
FB2: IC12.12 (+IN), IC13.11 (FB), R63.1, R70.2, R72.2
GND: C68.-, C70.2, C71.2, C72.2, C73.2, C75.2, C77.2, C79.2, C80.2, C81.2 (-), C82.-, C83.2, C84.1, C86.1, CH2.GND, D12.A, IC13.12 (GND), IC13.21 (SYNC), IC13.23 (GND), IC13.28 (GND), IC13.TP (GND_PAD), J5.1, J5.1.1, LED2.CC (C), Q8.3 (S), R54.1, R57.1, R61.1, R65.2, R66.1, R69.1, R70.1, R71.1, R75.1, R77.2, ZD5.A; also elsewhere on the board
INTVCC2: C75.1, D11.A, IC13.2 (INTVCC), R67.1, R68.2
ISET2: C69.1, IC10.1 (OUT), IC13.14 (CTRL1), R55.2
I_MON2: C84.2, R62.1; also elsewhere on the board
I_SET#2: R56.1; also elsewhere on the board
LOUT2: L4.2, R58.1
unnamed: LED2.RED (AR), R73.1
unnamed: IC13.20 (RT), R66.2
unnamed: C86.2, IC13.15 (SS)
unnamed: C87.1, R69.2
unnamed: Q9.3 (D), Q10.3 (D)
unnamed: LED2.GREEN (AG), Q9.2 (S)
unnamed: C70.1, D8.C, D10.C, IC13.3 (VIN)
unnamed: D9.C, Q6.1 (G), R53.2, ZD4.C
unnamed: D8.A, D9.A, Q6.3 (S)
unnamed: C87.2, IC13.18 (VC)
unnamed: IC13.9 (!FAULT), R68.1
unnamed: R58.1S, R59.2
unnamed: R58.2S, R60.2
unnamed: C78.2, R61.2
unnamed: C74.1, D11.C, IC13.27 (BOOST)
unnamed: IC13.19 (ISMON), R62.2
unnamed: IC12.2 (-IN), IC12.13 (-IN), IC12.14 (OUT)
unnamed: IC12.3 (+IN), R74.1, R75.2
unnamed: C69.2, IC10.2 (-IN), R54.2, R55.1
unnamed: IC10.3 (+IN), R56.2, R57.2
OE#2: IC13.4 (EV/UVLO), Q9.1 (G), R77.1; also elsewhere on the board
PE: C76.1, C83.1; also elsewhere on the board
PWM#2: IC13.22 (PWM), R67.2
Q6D: Q6.2 (D), Q6.4 (D), R52.2
SENSE1+1: C85.1, IC13.17 (SENSE+), R59.1
SENSE1-1: C85.2, IC13.16 (SENSE-), R60.1
SW2: C74.2, C78.1, D12.C, IC13.26 (SW), L4.1, Q7.3 (S), Q8.2 (D)
TG2: IC13.25 (TG), Q7.1 (G)
U_MON2: R64.1, R71.2; also elsewhere on the board
U_SET#2: R72.1; also elsewhere on the board
VOUT2+: C79.1, C80.1, C82.+, L5.1, R58.2, R63.2, R64.2, ZD4.A
VOUT_LC2+: C76.2, C77.1, C81.1 (+), CH2.TIP, J4.1, J4.1.1, L5.2, R65.1, ZD5.C
VREF2: C73.1, IC13.5 (VREF), IC13.10 (FBIN), IC13.13 (CTRL2), R74.2

Notes on the sheet:
Licensed under the TAPR Open Hardware License (www.tapr.org/OHL)
Repository: https://github.com/eez-open
More info at http://www.envox.hr/eez
CC mode detection
OE and CC indications
Power channel #2

Board: 2 copper layers, 155.0 x 95.0 mm, 249 parts (1 on the bottom side), 167 nets.

Other parts of the board:
EEZ_SIGNATURE: SIGNATURESMALL; SIGNATURE_5MM
U$2: RECYCLE_BIN1/8
U$4: ESD_SYMBOL

File dcm220/BOM/1-click-bom.csv (part):

"References","Qty","Description","Manufacturer","MPN","Manufacturer","MPN","Manufacturer","MPN","Manufacturer","MPN","Manufacturer","MPN","Digikey","Mouser","RS","Newark","Farnell",,,,,,,,
"C1, C2, C3, C56, C63, C76, C83",7,"10n/200V",,885342207005,"Würth Elektronik",885342207005,"Yageo","CC1206KRX7RABB103",,,,,"311-4491-1-ND",710885342207005,6698647,,491202,,,,,,,,
"C11",1,"330p",,"C0805C331J5GACTU","Walsin Technologies","0805N331J500CT","KEMET","C0805C331J5GACTU","Samsung","CL21C331JBANNNC",,,"399-1130-6-ND","80C0805C331J5G",7665941,,1414686,,,,,,,,
"C12, C55, C75",3,"22u",,"MC1206X226M100CT","Samsung","CL31A226KPHNNNE","Taiyo Yuden","LMK316ABJ226KL-T","Taiyo Yuden","LMK316ABJ226ML-T","Multicomp","MC1206X226M100CT","1276-1287-1-ND","963LMK316ABJ226MLT",1721532,,2112754,,,,,,,,
"C15, C19, C23, C34, C35, C66, C86",7,"10n",,"VJ0805Y103JXXPW1BC","AVX","08055C103KAT2A","Würth Elektronik",885012207122,"Murata","GRM033R61E103KA12D","Vishay","VJ0805Y103JXXPW1BC","490-7194-6-ND","58108055C103K",1359020,,499225,,,,,,,,
"C16",1,"33p",,"MC0805N330J500CT","KEMET","C0805C330J5GACTU","Samsung","CL21C330JBANNNC","Multicomp","MC0805N330J500CT",,,"1276-1105-6-ND","80C0805C330J5G",2644264,,1759197,,,,,,,,
"C36",1,"1n",,"VJ0805A102JXACW1BC","Würth Elektronik",885012007040,"Würth Elektronik",885012007063,"Vishay","VJ0805A102JXACW1BC",,,"720-1634-6-ND",710885012007063,1927618,,2533866,,,,,,,,
"C38, C53, C57, C73, C77",5,"1u",,"VJ0805Y105KXXTW1BC","KEMET","C0805C105K4RACTU","Yageo","CC0805MKX7R7BB105","Taiyo Yuden","EMK212B7105KG-T","Vishay","VJ0805Y105KXXTW1BC","399-1284-6-ND","80C0805C105K4R"," 451-5770 ",,2896566,,,,,,,,
"C39, C41, C42, C43, C44, C67, C87",7,"4n7",,"GRM2165C1H472JA01D","Würth Elektronik",885012007025,"TDK","C2012C0G1H472J060AA","Murata","GRM2165C1H472JA01D",,,"490-3044-6-ND","810C2012C0G1H472J1",7414529,,1828942,,,,,,,,
"C4, C5, C14, C29, C49, C70",6,"4u7",,"C3216X7R1E475K160AC","KEMET","C1206C475K3RACTU","TDK","C3216X7R1E475K160AC","Samsung","CL21B475KOFNFNE","Taiyo Yuden","EMK316B7475ML-T","445-1606-6-ND","810C3216X7R1E475K",6911221,,1907356,,,,,,,,
"C46, C68",2,"EEEFK1H470",,"EEEFK1H470P","Panasonic","EEEFK1H470P",,,,,,,"PCE3815CT-ND","667EEEFK1H470P","5370590P",,9695931,,,,,,,,
"C48, C69",2,"100p",,"C0805C101JAGACTU","KEMET","C0805C101JAGAC7800","KEMET","C0805C101JAGACTU","KEMET","C0805C101K5GACTU","Yageo","CC0805JRNP09BN101","399-1121-1-ND","80C0805C101K5G",4613997,,2896861,,,,,,,,
"C50, C52, C71, C72",4,"10u",,"GRT31CR61H106KE01L","TDK","C3216X7R1H106K160AC","Samsung","CL31A106MBHNNNE","Murata","GRT31CR61H106KE01L","Taiyo Yuden","UMK316BBJ106KL-T","490-12456-1-ND","81GRT31CR61H106KE1L",1034163,,2672214,,,,,,,,
"C54, C74",2,"220n",,"MC0805B224J250CT","Samsung","CL21B224KAFNNNG","Taiyo Yuden","EMK212B7224KG-T","Multicomp","MC0805B224J250CT","Taiyo Yuden","UMK212B7224KG-T","587-1287-6-ND","963UMK212B7224KGT",1034126,,2320828,,,,,,,,
"C59, C60, C79, C80",6,"22u",,"MC1210X226K250CT","Yageo","CC1210KKX7R8BB226","Samsung","CL32A226KAJNNNE","Samsung","CL32A226MAJNNNE","Multicomp","MC1210X226K250CT","1276-3373-6-ND","603CC121KKX7R8BB226",7661182,,3010209,,,,,,,,
"C6, C9, C21",3,"2u2",,"C1206C225K5RECTU","KEMET","C1206C225K5RECTU","KEMET","C1206C225M5REC7210","Samsung","CL31A225KB9LNNC","Taiyo Yuden","UMK316B7225KLHT","587-3717-6-ND","80C1206C225K5RECTU",1843509,,"2991428RL",,,,,,,,
"C61, C81",2,"EEEFK1V470P",,"EEEFK1V470P","Panasonic","EEEFK1V470P",,,,,,,"PCE3842CT-ND","667EEEFK1V470P",5370657,,9695850,,,,,,,,
"C62, C82",2,"UVZ1E102MPD",,"MCGPR25V108M10X21","Multicomp","MCGPR25V108M10X21","Nichicon","UVZ1E102MPD",,,,,"493-1305-ND","647UVZ1E102MPD",8454685,,9451226,,,,,,,,
"C64, C84",2,"470p",,"MC0805N471J500CT","EPCOS","0805CG471J9BB","Würth Elektronik",885012007038,"Multicomp","MC0805N471J500CT",,,"732-7837-1-ND",710885012007038,378700,,2533864,,,,,,,,
"C65, C85",2,"33n",,"MC0805B333K250CT","AVX","08051C333KAT2A","Würth Elektronik",885012207069,"Samsung","CL21B333KBANNNC","Multicomp","MC0805B333K250CT","1276-1796-1-ND","58108051C333KAT2A",1356639,,1833886,,,,,,,,
"C7, C8, C10, C17, C18, C20, C24, C26, C27, C28, C30, C31, C37, C40, C45, C47, C51",17,"100n",,"C0603C104K4RAC7081","KEMET","C0603C104K4RAC7081","KEMET","C0603C104M4RACTU","Murata","GCM188R71C104KA37D","Vishay","VJ0603Y104KXJAC","490-4774-6-ND","80C0603C104M4R",3936952,,2522597,,,,,,,,
"D1, D2, D3, D4, D6, D8, D9, D11",8,"SKL16",,"RB160MM-60TR","Rohm","RB160MM-60TR",,,,,,,"RB160MM-60CT-ND","755RB160MM60TR",1246774,,2673070,,,,,,,,
"FB1",1,"BLM18AG102SH1D",,"MMZ1608Y102B","Murata","BLM18AG102SH1D","TDK","MMZ1608Y102B","TDK","MMZ1608Y102BT",,,"490-7809-1-ND","81BLM18AG102SH1D","8390803P",,1669708,,,,,,,,
"IC1",1,"Si8662AB-B-IS1",,"SI8662AB-B-IS1","Silicon Labs","SI8662AB-B-IS1",,,,,,,"SI8662AB-B-IS1-ND","634SI8662ABBIS1",8232062,,2423351,,,,,,,,
"IC10",1,"MC33272ADR2G",,"MC33272ADR2G","ON Semiconductor","MC33272ADR2G",,,,,,,"MC33272ADR2GOSDKR-ND","863MC33272ADR2G",7737778,,2531389,,,,,,,,
"IC11, IC13",2,"LT3763EFE#PBF","Analog Devices / Linear Technology","LT3763EFE#PBF",,,,,,,,,"LT3763EFE#PBF-ND","584LT3763EFE#PBF",,,2293099,,,,,,,,
"IC12",1,"MC33274ADR2G",,"MC33274ADR2G","ON Semiconductor","MC33274ADR2G",,,,,,,"MC33274ADR2GOSDKR-ND","863MC33274ADR2G",7737787,,2531387,,,,,,,,
"IC2",1,"TPS54060DGQ",,"TPS54060DGQ .","Texas Instruments","TPS54060DGQ","Texas Instruments","TPS54060DGQR",,,,,"296-37148-1-ND","595TPS54060DGQR",6989079,,1710820,,,,,,,,
"IC3",1,"Si8641AB-B-IS1",,"Si8641AB-B-IS1","Silicon Labs","SI8641AB-B-IS1",,,,,,,"SI8641AB-B-IS1-ND","634SI8641ABBIS1","8232000P",,2423288,,,,,,,,
"IC4",1,"M24C32-WMN6P",,"M24C32-WMN6P","STMicroelectronics","M24C32-WMN6P",,,,,,,,"511M24C32WMN6P",1686383,,1224413,,,,,,,,
"IC5",1,"LP2985-33DBVR",,"LP2985A-33DBVTE4 .","Texas Instruments","LP2985-33DBVR","Texas Instruments","LP2985-33DBVT","Texas Instruments","LP2985A-33DBVTE4",,,"296-18476-6-ND","595LP298533DBVR",6606733,,3122176,,,,,,,,
"IC6",1,"74HC2G04GW,125",,"74HC2G04GW,125","Nexperia","74HC2G04GW,125",,,,,,,"1727-6045-1-ND","771HC2G04GW125",1532919,,2777732,,,,,,,,
"IC8",1,"STM32F373C8T6",,"STM32F373C8T6","STMicroelectronics","STM32F373C8T6",,,,,,,"497-13306-ND","511STM32F373C8T6","7959164P",,2333274,,,,,,,,
"IC9",1,"TL431BIDBZR",,"TL431BCDBZR","Texas Instruments","TL431BCDBZR","Nexperia","TL431BCDBZR","Nexperia","TL431BIDBZR,215",,,"1727-4257-1-ND","771TL431BIDBZR215",7974826,,2095470,,,,,,,,
"J1",1,4907,"Keystone",4907,,,,,,,,,"36-4907-ND",5344907,,,,,,,,,,,
"J2, J4",2,"571-0500",,"571-0500-01","RS Pro",1036511,"Deltron","571-0500","Deltron","571-0500-01",,,,1646219,1036511,,1101127,,,,,,,,
"J3, J5",2,"571-0100",,"571-0100-01","RS Pro",1036527,"Deltron","571-0100","Deltron","571-0100-01",,,,1646218,1036527,,1494595,,,,,,,,
"L1",1,"RN112-4-02-0M7","Schaffner","RN112-4-02-0M7",,,,,,,,,"817-2100-ND","631RN1124020M7",,,2730089,,,,,,,,
"L2, L4",2,"125CDMCCDS-330MC",,7443551331,"Sumida","125CDMCCDS-330MC","Würth Elektronik",7443551331,,,,,"732-3881-1-ND",7107443551331,,,2211631,,,,,,,,
"L3, L5",2,"HPI0630-3R3",,"IHLP2020CZER3R3M11","Vishay","IHLP2020CZER3R3M11","TDK","VLS6045AF-3R3N",,,,,"541-1237-6-ND","70IHLP2020CZER3R3M1",,,1741325,,,,,,,,
"LED1, LED2",2,"WP42WUM/EGW","Kingbright","WP42WUM/EGW",,,,,,,,,"754-1718-ND","604WP42WUM/EGW",,,,,,,,,,,
"NTC1, NTC2",2,"NTCS0805E3103JMT",,"NTCS0805E3103JMT","Vishay","NTCS0805E3103JMT",,,,,,,"BC2292DKR-ND",594238161553103,1793950,,2103177,,,,,,,,
"Q1, Q6",2,"BSP716NH6327XTSA1",,"BSP716NH6327XTSA1","Infineon","BSP716NH6327XTSA1",,,,,,,"BSP716NH6327XTSA1CT-ND","726BSP716NH6327XTSA",,,2803380,,,,,,,,
"Q2, Q3, Q7, Q8",4,"NTD5867NLT4G",,"NTD5867NLT4G","ON Semiconductor","NTD5867NLT4G",,,,,,,"NTD5867NLT4GOSDKR-ND","863NTD5867NLT4G",7192901,,1879964,,,,,,,,
"Q4, Q9",2,"BSS205NH6327XTSA1",,"BSS205NH6327XTSA1","Infineon","BSS205NH6327XTSA1",,,,,,,"BSS205NH6327XTSA1DKR-ND","726BSS205NH6327XT",8922374,,2480648,,,,,,,,
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
## Code that names these connections

File mcu/CubeMX/EEZ DIB STM32F7 r1B4.ioc (part):

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Mcu.Name=STM32F769IGTx
Mcu.Package=LQFP176
Mcu.UserName=STM32F769IGTx
PA0/WKUP.Mode=MII
PA0/WKUP.Signal=ETH_CRS
PA1.Mode=MII
PA1.Signal=ETH_RX_CLK
PA10.Mode=OTG/Dual_Role_Device
PA10.Signal=USB_OTG_FS_ID
PA11.Mode=OTG/Dual_Role_Device
PA11.Signal=USB_OTG_FS_DM
PA12.Mode=OTG/Dual_Role_Device
PA12.Signal=USB_OTG_FS_DP
PA13.Mode=Trace_Asynchronous_SW
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Trace_Asynchronous_SW
PA14.Signal=SYS_JTCK-SWCLK
PA15.GPIOParameters=GPIO_Label
PA15.GPIO_Label=SPI5_IRQ
PA15.Signal=GPIO_Input
PA2.Mode=MII
PA2.Signal=ETH_MDIO
PA3.Mode=MII
PA3.Signal=ETH_COL
PA4.Signal=COMP_DAC1_group
PA5.GPIOParameters=GPIO_Speed
PA5.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PA5.Mode=RGB666
PA5.Signal=LTDC_R4
PA6.GPIOParameters=GPIO_Speed
PA6.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PA6.Mode=RGB666
PA6.Signal=LTDC_G2
PA7.Mode=MII
PA7.Signal=ETH_RX_DV
PA8.GPIOParameters=GPIO_Label
PA8.GPIO_Label=SPI2_IRQ
PA8.Signal=GPIO_Input
PA9.Mode=Activate_VBUS
PA9.Signal=USB_OTG_FS_VBUS
PB0.GPIOParameters=GPIO_Speed
PB0.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PB0.Mode=RGB666
PB0.Signal=LTDC_R3
PB1.GPIOParameters=GPIO_Speed
PB1.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PB1.Mode=RGB666
PB1.Signal=LTDC_R6
PB10.Mode=Activate Rx Err signal
PB10.Signal=ETH_RX_ER
PB11.Mode=MII
PB11.Signal=ETH_TX_EN
PB12.Mode=MII
PB12.Signal=ETH_TXD0
PB13.Mode=MII
PB13.Signal=ETH_TXD1
PB14.Mode=Full_Duplex_Master
PB14.Signal=SPI2_MISO
PB15.GPIOParameters=GPIO_Label
PB15.GPIO_Label=TFT_BRIGHTNESS
PB15.Signal=S_TIM12_CH2
PB2.GPIOParameters=GPIO_PuPd,GPIO_Label
PB2.GPIO_Label=NFAULT
PB2.GPIO_PuPd=GPIO_PULLUP
PB2.Signal=GPIO_Input
PB3.Mode=Trace_Asynchronous_SW
PB3.Signal=SYS_JTDO-SWO
PB4.GPIOParameters=GPIO_Label
PB4.GPIO_Label=UART_TX/DOUT1
PB4.Mode=Asynchronous
PB4.Signal=UART7_TX
PB5.GPIOParameters=GPIO_Label
PB5.GPIO_Label=DOUT2
PB5.Signal=GPIO_Output
PB6.Mode=I2C
PB6.Signal=I2C1_SCL
PB7.Mode=I2C
PB7.Signal=I2C1_SDA
PB8.Mode=MII
PB8.Signal=ETH_TXD3
PB9.GPIOParameters=GPIO_Label
PB9.GPIO_Label=SPI4_IRQ
PB9.Signal=GPIO_Input
PC0.GPIOParameters=GPIO_Speed
PC0.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PC0.Mode=RGB666
PC0.Signal=LTDC_R5
PC1.Mode=MII
PC1.Signal=ETH_MDC
PC10.GPIOParameters=GPIO_Speed
PC10.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PC10.Mode=RGB666
PC10.Signal=LTDC_R2
PC11.GPIOParameters=GPIO_Label
PC11.GPIO_Label=SD_DETECT
PC11.Signal=GPIO_Input
PC12.Mode=SD_1_bit
PC12.Signal=SDMMC1_CK
PC13.GPIOParameters=GPIO_Label
PC13.GPIO_Label=DIN2
PC13.Signal=GPIO_Input
PC14/OSC32_IN.Mode=LSE-External-Oscillator
PC14/OSC32_IN.Signal=RCC_OSC32_IN
PC15/OSC32_OUT.Mode=LSE-External-Oscillator
PC15/OSC32_OUT.Signal=RCC_OSC32_OUT
PC2.Mode=MII
PC2.Signal=ETH_TXD2
PC3.Mode=MII
PC3.Signal=ETH_TX_CLK
PC4.Mode=MII
PC4.Signal=ETH_RXD0
PC5.Mode=MII
PC5.Signal=ETH_RXD1
PC6.GPIOParameters=GPIO_PuPd,GPIO_Label
PC6.GPIO_Label=ENC_A
PC6.GPIO_PuPd=GPIO_PULLUP
PC6.Signal=S_TIM8_CH1
PC7.GPIOParameters=GPIO_PuPd,GPIO_Label
PC7.GPIO_Label=ENC_B
PC7.GPIO_PuPd=GPIO_PULLUP
PC7.Signal=S_TIM8_CH2
PC8.Mode=SD_1_bit
PC8.Signal=SDMMC1_D0
PC9.GPIOParameters=GPIO_Speed,GPIO_Label
PC9.GPIO_Label=MCLK_25
PC9.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PC9.Mode=Clock-out-2
PC9.Signal=RCC_MCO_2
PD0.Signal=FMC_D2_DA2
PD1.Signal=FMC_D3_DA3
PD10.Signal=FMC_D15_DA15
PD11.GPIOParameters=GPIO_Speed,GPIO_Label
PD11.GPIO_Label=SPI2_CSB
PD11.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PD11.Signal=GPIO_Output
PD12.GPIOParameters=GPIO_Speed,GPIO_Label
PD12.GPIO_Label=SPI2_CSA
PD12.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PD12.Signal=GPIO_Output
PD13.GPIOParameters=GPIO_PuPd,GPIO_Label
PD13.GPIO_Label=OE_SYNC
PD13.GPIO_PuPd=GPIO_NOPULL
PD13.Signal=GPIO_Output
PD14.Signal=FMC_D0_DA0
PD15.Signal=FMC_D1_DA1
PD2.Mode=SD_1_bit
PD2.Signal=SDMMC1_CMD
PD3.GPIOParameters=GPIO_Speed
PD3.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PD3.Mode=RGB666
PD3.Signal=LTDC_G7
PD4.GPIOParameters=GPIO_Label
PD4.GPIO_Label=USB_OTG_FS_OC
PD4.Signal=GPIO_Input
PD5.GPIOParameters=GPIO_Label
PD5.GPIO_Label=USB_OTG_FS_PSO
PD5.Signal=GPIO_Output
PD6.GPIOParameters=GPIO_Speed
PD6.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PD6.Mode=RGB666
PD6.Signal=LTDC_B2
PD7.GPIOParameters=GPIO_Label
PD7.GPIO_Label=IRQ_TOUCH
PD7.Signal=GPIO_Input
PD8.Signal=FMC_D13_DA13
PD9.Signal=FMC_D14_DA14
PE0.Signal=FMC_NBL0
PE1.Signal=FMC_NBL1
PE10.Signal=FMC_D7_DA7
PE11.Signal=FMC_D8_DA8
PE12.Signal=FMC_D9_DA9
PE13.Signal=FMC_D10_DA10
PE14.Signal=FMC_D11_DA11
PE15.Signal=FMC_D12_DA12
PE2.Mode=Full_Duplex_Master
PE2.Signal=SPI4_SCK
PE3.GPIOParameters=GPIO_Speed,GPIO_Label
PE3.GPIO_Label=SPI4_CSA
PE3.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PE3.Signal=GPIO_Output
PE4.GPIOParameters=GPIO_Speed,GPIO_Label
PE4.GPIO_Label=SPI4_CSB
PE4.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PE4.Signal=GPIO_Output
PE5.Mode=Full_Duplex_Master
PE5.Signal=SPI4_MISO
PE6.Mode=Full_Duplex_Master
PE6.Signal=SPI4_MOSI
PE7.Signal=FMC_D4_DA4
PE8.Signal=FMC_D5_DA5
PE9.Signal=FMC_D6_DA6
PF0.Signal=FMC_A0
PF1.Signal=FMC_A1
PF10.GPIOParameters=GPIO_Speed
PF10.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PF10.Mode=RGB666
PF10.Signal=LTDC_DE
PF11.Signal=FMC_SDNRAS
PF12.Signal=FMC_A6
PF13.Signal=FMC_A7
PF14.Signal=FMC_A8
PF15.Signal=FMC_A9
PF2.Signal=FMC_A2
PF3.Signal=FMC_A3
PF4.Signal=FMC_A4
PF5.Signal=FMC_A5
PF6.GPIOParameters=GPIO_Label
PF6.GPIO_Label=UART_RX/DIN1
PF6.Mode=Asynchronous
PF6.Signal=UART7_RX
PF7.Mode=Full_Duplex_Master
PF7.Signal=SPI5_SCK
PF8.Mode=Full_Duplex_Master
PF8.Signal=SPI5_MISO
PF9.Mode=Full_Duplex_Master
PF9.Signal=SPI5_MOSI
PG0.Signal=FMC_A10
PG1.Signal=FMC_A11
PG10.GPIOParameters=GPIO_Speed
PG10.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PG10.Mode=RGB666
PG10.Signal=LTDC_G3
PG11.GPIOParameters=GPIO_Speed
PG11.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PG11.Mode=RGB666
PG11.Signal=LTDC_B3
PG12.GPIOParameters=GPIO_Speed
PG12.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PG12.Mode=RGB666
PG12.Signal=LTDC_B4
PG13.GPIOParameters=GPIO_Speed,GPIO_Label
PG13.GPIO_Label=SPI5_CSB
PG13.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PG13.Signal=GPIO_Output
PG14.GPIOParameters=GPIO_Speed,GPIO_Label
PG14.GPIO_Label=SPI5_CSA
PG14.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PG14.Signal=GPIO_Output
PG15.Signal=FMC_SDNCAS
PG2.GPIOParameters=GPIO_PuPd,GPIO_Label
PG2.GPIO_Label=PWR_DIRECT
PG2.GPIO_PuPd=GPIO_NOPULL
PG2.Signal=GPIO_Output
PG3.GPIOParameters=GPIO_PuPd,GPIO_Label
PG3.GPIO_Label=PWR_SSTART
PG3.GPIO_PuPd=GPIO_NOPULL
PG3.Signal=GPIO_Output
PG4.Signal=FMC_A14_BA0
PG5.Signal=FMC_A15_BA1
PG6.GPIOParameters=GPIO_Speed
PG6.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PG6.Mode=RGB666
PG6.Signal=LTDC_R7
PG7.GPIOParameters=GPIO_Speed
PG7.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PG7.Mode=RGB666
PG7.Signal=LTDC_CLK
PG8.Signal=FMC_SDCLK
PG9.GPIOParameters=GPIO_PuPd,GPIO_Label,GPIO_ModeDefaultOutputPP
PG9.GPIO_Label=USER_SW
PG9.GPIO_ModeDefaultOutputPP=GPIO_MODE_OUTPUT_PP
PG9.GPIO_PuPd=GPIO_NOPULL
PG9.Signal=GPIO_Output
PH0/OSC_IN.Mode=HSE-External-Oscillator
PH0/OSC_IN.Signal=RCC_OSC_IN
PH1/OSC_OUT.Mode=HSE-External-Oscillator
PH1/OSC_OUT.Signal=RCC_OSC_OUT
PH2.Mode=SdramChipSelect1_1
PH2.Signal=FMC_SDCKE0
PH3.Mode=SdramChipSelect1_1
PH3.Signal=FMC_SDNE0
PH4.GPIOParameters=GPIO_Speed
PH4.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PH4.Mode=RGB666
PH4.Signal=LTDC_G4
PH5.Signal=FMC_SDNWE
PH6.Mode=MII
PH6.Signal=ETH_RXD2
PH7.Mode=MII
PH7.Signal=ETH_RXD3
PI0.GPIOParameters=GPIO_Speed
PI0.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PI0.Mode=RGB666
PI0.Signal=LTDC_G5
PI1.Mode=Full_Duplex_Master
PI1.Signal=SPI2_SCK
PI10.GPIOParameters=GPIO_Speed
PI10.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PI10.Mode=RGB666
PI10.Signal=LTDC_HSYNC
PI11.GPIOParameters=GPIO_Speed
PI11.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PI11.Mode=RGB666
PI11.Signal=LTDC_G6
PI3.Mode=Full_Duplex_Master
PI3.Signal=SPI2_MOSI
PI4.GPIOParameters=GPIO_Label
PI4.GPIO_Label=ENC_SW
PI4.Signal=GPIO_Input
PI5.GPIOParameters=GPIO_Speed
PI5.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PI5.Mode=RGB666
PI5.Signal=LTDC_B5
PI6.GPIOParameters=GPIO_Speed
PI6.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PI6.Mode=RGB666
PI6.Signal=LTDC_B6
PI7.GPIOParameters=GPIO_Speed
PI7.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PI7.Mode=RGB666
PI7.Signal=LTDC_B7
PI9.GPIOParameters=GPIO_Speed
PI9.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PI9.Mode=RGB666
PI9.Signal=LTDC_VSYNC
RCC.HSE_VALUE=25000000
RCC.SYSCLKFreq_VALUE=216000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=EEZ H25005 MCU board v0.3

File mcu/CubeMX/EEZ DIB STM32F7 r1B2.ioc (part):

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Mcu.Name=STM32F769IGTx
Mcu.Package=LQFP176
Mcu.UserName=STM32F769IGTx
PA0/WKUP.Mode=MII
PA0/WKUP.Signal=ETH_CRS
PA1.Mode=MII
PA1.Signal=ETH_RX_CLK
PA10.Mode=OTG/Dual_Role_Device
PA10.Signal=USB_OTG_FS_ID
PA11.Mode=OTG/Dual_Role_Device
PA11.Signal=USB_OTG_FS_DM
PA12.Mode=OTG/Dual_Role_Device
PA12.Signal=USB_OTG_FS_DP
PA13.Mode=Trace_Asynchronous_SW
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Trace_Asynchronous_SW
PA14.Signal=SYS_JTCK-SWCLK
PA15.GPIOParameters=GPIO_Label
PA15.GPIO_Label=SPI5_IRQ
PA15.Signal=GPIO_Input
PA2.Mode=MII
PA2.Signal=ETH_MDIO
PA3.Mode=MII
PA3.Signal=ETH_COL
PA4.Signal=COMP_DAC1_group
PA5.GPIOParameters=GPIO_Speed
PA5.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PA5.Mode=RGB666
PA5.Signal=LTDC_R4
PA6.GPIOParameters=GPIO_Speed
PA6.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PA6.Mode=RGB666
PA6.Signal=LTDC_G2
PA7.Mode=MII
PA7.Signal=ETH_RX_DV
PA8.GPIOParameters=GPIO_Label
PA8.GPIO_Label=SPI2_IRQ
PA8.Signal=GPIO_Input
PA9.Mode=Activate_VBUS
PA9.Signal=USB_OTG_FS_VBUS
PB0.GPIOParameters=GPIO_Speed
PB0.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PB0.Mode=RGB666
PB0.Signal=LTDC_R3
PB1.GPIOParameters=GPIO_Speed
PB1.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PB1.Mode=RGB666
PB1.Signal=LTDC_R6
PB10.Mode=Activate Rx Err signal
PB10.Signal=ETH_RX_ER
PB11.Mode=MII
PB11.Signal=ETH_TX_EN
PB12.Mode=MII
PB12.Signal=ETH_TXD0
PB13.Mode=MII
PB13.Signal=ETH_TXD1
PB14.Mode=Full_Duplex_Master
PB14.Signal=SPI2_MISO
PB15.GPIOParameters=GPIO_Label
PB15.GPIO_Label=TFT_BRIGHTNESS
PB15.Signal=S_TIM12_CH2
PB2.GPIOParameters=GPIO_PuPd,GPIO_Label
PB2.GPIO_Label=NFAULT
PB2.GPIO_PuPd=GPIO_PULLUP
PB2.Signal=GPIO_Input
PB3.Mode=Trace_Asynchronous_SW
PB3.Signal=SYS_JTDO-SWO
PB5.GPIOParameters=GPIO_Label
PB5.GPIO_Label=USER_SW
PB5.Signal=GPIO_Output
PB6.Mode=I2C
PB6.Signal=I2C1_SCL
PB7.Mode=I2C
PB7.Signal=I2C1_SDA
PB8.Mode=MII
PB8.Signal=ETH_TXD3
PB9.GPIOParameters=GPIO_Label
PB9.GPIO_Label=SPI4_IRQ
PB9.Signal=GPIO_Input
PC0.GPIOParameters=GPIO_Speed
PC0.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PC0.Mode=RGB666
PC0.Signal=LTDC_R5
PC1.Mode=MII
PC1.Signal=ETH_MDC
PC10.GPIOParameters=GPIO_Speed
PC10.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PC10.Mode=RGB666
PC10.Signal=LTDC_R2
PC11.GPIOParameters=GPIO_PuPd,GPIO_Label
PC11.GPIO_Label=OUT_PAR
PC11.GPIO_PuPd=GPIO_NOPULL
PC11.Signal=GPIO_Output
PC12.Mode=SD_1_bit
PC12.Signal=SDMMC1_CK
PC13.GPIOParameters=GPIO_Label
PC13.GPIO_Label=DIN2
PC13.Signal=GPIO_Input
PC14/OSC32_IN.GPIOParameters=GPIO_Speed,GPIO_Label
PC14/OSC32_IN.GPIO_Label=DOUT1
PC14/OSC32_IN.GPIO_Speed=GPIO_SPEED_FREQ_LOW
PC14/OSC32_IN.Signal=GPIO_Output
PC15/OSC32_OUT.GPIOParameters=GPIO_Label
PC15/OSC32_OUT.GPIO_Label=DOUT2
PC15/OSC32_OUT.Signal=GPIO_Output
PC2.Mode=MII
PC2.Signal=ETH_TXD2
PC3.Mode=MII
PC3.Signal=ETH_TX_CLK
PC4.Mode=MII
PC4.Signal=ETH_RXD0
PC5.Mode=MII
PC5.Signal=ETH_RXD1
PC6.GPIOParameters=GPIO_PuPd,GPIO_Label
PC6.GPIO_Label=ENC_A
PC6.GPIO_PuPd=GPIO_PULLUP
PC6.Signal=S_TIM8_CH1
PC7.GPIOParameters=GPIO_PuPd,GPIO_Label
PC7.GPIO_Label=ENC_B
PC7.GPIO_PuPd=GPIO_PULLUP
PC7.Signal=S_TIM8_CH2
PC8.Mode=SD_1_bit
PC8.Signal=SDMMC1_D0
PC9.GPIOParameters=GPIO_Speed,GPIO_Label
PC9.GPIO_Label=MCLK_25
PC9.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PC9.Mode=Clock-out-2
PC9.Signal=RCC_MCO_2
PD0.Signal=FMC_D2_DA2
PD1.Signal=FMC_D3_DA3
PD10.Signal=FMC_D15_DA15
PD11.GPIOParameters=GPIO_Speed,GPIO_Label
PD11.GPIO_Label=SPI2_CSB
PD11.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PD11.Signal=GPIO_Output
PD12.GPIOParameters=GPIO_Speed,GPIO_Label
PD12.GPIO_Label=SPI2_CSA
PD12.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PD12.Signal=GPIO_Output
PD13.GPIOParameters=GPIO_PuPd,GPIO_Label
PD13.GPIO_Label=OE_SYNC
PD13.GPIO_PuPd=GPIO_NOPULL
PD13.Signal=GPIO_Output
PD14.Signal=FMC_D0_DA0
PD15.Signal=FMC_D1_DA1
PD2.Mode=SD_1_bit
PD2.Signal=SDMMC1_CMD
PD3.GPIOParameters=GPIO_Speed
PD3.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PD3.Mode=RGB666
PD3.Signal=LTDC_G7
PD4.GPIOParameters=GPIO_Label
PD4.GPIO_Label=USB_OTG_FS_OC
PD4.Signal=GPIO_Input
PD5.GPIOParameters=GPIO_Label
PD5.GPIO_Label=USB_OTG_FS_PSO
PD5.Signal=GPIO_Output
PD6.GPIOParameters=GPIO_Speed
PD6.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PD6.Mode=RGB666
PD6.Signal=LTDC_B2
PD7.GPIOParameters=GPIO_Label
PD7.GPIO_Label=IRQ_TOUCH
PD7.Signal=GPIO_Input
PD8.Signal=FMC_D13_DA13
PD9.Signal=FMC_D14_DA14
PE0.Signal=FMC_NBL0
PE1.Signal=FMC_NBL1
PE10.Signal=FMC_D7_DA7
PE11.Signal=FMC_D8_DA8
PE12.Signal=FMC_D9_DA9
PE13.Signal=FMC_D10_DA10
PE14.Signal=FMC_D11_DA11
PE15.Signal=FMC_D12_DA12
PE2.Mode=Full_Duplex_Master
PE2.Signal=SPI4_SCK
PE3.GPIOParameters=GPIO_Speed,GPIO_Label
PE3.GPIO_Label=SPI4_CSA
PE3.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PE3.Signal=GPIO_Output
PE4.GPIOParameters=GPIO_Speed,GPIO_Label
PE4.GPIO_Label=SPI4_CSB
PE4.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PE4.Signal=GPIO_Output
PE5.Mode=Full_Duplex_Master
PE5.Signal=SPI4_MISO
PE6.Mode=Full_Duplex_Master
PE6.Signal=SPI4_MOSI
PE7.Signal=FMC_D4_DA4
PE8.Signal=FMC_D5_DA5
PE9.Signal=FMC_D6_DA6
PF0.Signal=FMC_A0
PF1.Signal=FMC_A1
PF10.GPIOParameters=GPIO_Speed
PF10.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PF10.Mode=RGB666
PF10.Signal=LTDC_DE
PF11.Signal=FMC_SDNRAS
PF12.Signal=FMC_A6
PF13.Signal=FMC_A7
PF14.Signal=FMC_A8
PF15.Signal=FMC_A9
PF2.Signal=FMC_A2
PF3.Signal=FMC_A3
PF4.Signal=FMC_A4
PF5.Signal=FMC_A5
PF6.GPIOParameters=GPIO_Label
PF6.GPIO_Label=SD_DETECT
PF6.Signal=GPIO_Input
PF7.Mode=Full_Duplex_Master
PF7.Signal=SPI5_SCK
PF8.Mode=Full_Duplex_Master
PF8.Signal=SPI5_MISO
PF9.Mode=Full_Duplex_Master
PF9.Signal=SPI5_MOSI
PG0.Signal=FMC_A10
PG1.Signal=FMC_A11
PG10.GPIOParameters=GPIO_Speed
PG10.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PG10.Mode=RGB666
PG10.Signal=LTDC_G3
PG11.GPIOParameters=GPIO_Speed
PG11.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PG11.Mode=RGB666
PG11.Signal=LTDC_B3
PG12.GPIOParameters=GPIO_Speed
PG12.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PG12.Mode=RGB666
PG12.Signal=LTDC_B4
PG13.GPIOParameters=GPIO_Speed,GPIO_Label
PG13.GPIO_Label=SPI5_CSB
PG13.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PG13.Signal=GPIO_Output
PG14.GPIOParameters=GPIO_Speed,GPIO_Label
PG14.GPIO_Label=SPI5_CSA
PG14.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PG14.Signal=GPIO_Output
PG15.Signal=FMC_SDNCAS
PG2.GPIOParameters=GPIO_PuPd,GPIO_Label
PG2.GPIO_Label=PWR_DIRECT
PG2.GPIO_PuPd=GPIO_NOPULL
PG2.Signal=GPIO_Output
PG3.GPIOParameters=GPIO_PuPd,GPIO_Label
PG3.GPIO_Label=PWR_SSTART
PG3.GPIO_PuPd=GPIO_NOPULL
PG3.Signal=GPIO_Output
PG4.Signal=FMC_A14_BA0
PG5.Signal=FMC_A15_BA1
PG6.GPIOParameters=GPIO_Speed
PG6.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PG6.Mode=RGB666
PG6.Signal=LTDC_R7
PG7.GPIOParameters=GPIO_Speed
PG7.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PG7.Mode=RGB666
PG7.Signal=LTDC_CLK
PG8.Signal=FMC_SDCLK
PG9.GPIOParameters=GPIO_PuPd,GPIO_Label,GPIO_ModeDefaultOutputPP
PG9.GPIO_Label=OUT_SER
PG9.GPIO_ModeDefaultOutputPP=GPIO_MODE_OUTPUT_PP
PG9.GPIO_PuPd=GPIO_NOPULL
PG9.Signal=GPIO_Output
PH0/OSC_IN.Mode=HSE-External-Oscillator
PH0/OSC_IN.Signal=RCC_OSC_IN
PH1/OSC_OUT.Mode=HSE-External-Oscillator
PH1/OSC_OUT.Signal=RCC_OSC_OUT
PH2.Mode=SdramChipSelect1_1
PH2.Signal=FMC_SDCKE0
PH3.Mode=SdramChipSelect1_1
PH3.Signal=FMC_SDNE0
PH4.GPIOParameters=GPIO_Speed
PH4.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PH4.Mode=RGB666
PH4.Signal=LTDC_G4
PH5.Signal=FMC_SDNWE
PH6.Mode=MII
PH6.Signal=ETH_RXD2
PH7.Mode=MII
PH7.Signal=ETH_RXD3
PI0.GPIOParameters=GPIO_Speed
PI0.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PI0.Mode=RGB666
PI0.Signal=LTDC_G5
PI1.Mode=Full_Duplex_Master
PI1.Signal=SPI2_SCK
PI10.GPIOParameters=GPIO_Speed
PI10.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PI10.Mode=RGB666
PI10.Signal=LTDC_HSYNC
PI11.GPIOParameters=GPIO_Speed
PI11.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PI11.Mode=RGB666
PI11.Signal=LTDC_G6
PI3.Mode=Full_Duplex_Master
PI3.Signal=SPI2_MOSI
PI4.GPIOParameters=GPIO_Label
PI4.GPIO_Label=ENC_SW
PI4.Signal=GPIO_Input
PI5.GPIOParameters=GPIO_Speed
PI5.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PI5.Mode=RGB666
PI5.Signal=LTDC_B5
PI6.GPIOParameters=GPIO_Speed
PI6.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PI6.Mode=RGB666
PI6.Signal=LTDC_B6
PI7.GPIOParameters=GPIO_Speed
PI7.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PI7.Mode=RGB666
PI7.Signal=LTDC_B7
PI8.GPIOParameters=GPIO_Label
PI8.GPIO_Label=DIN1
PI8.Signal=GPIO_Input
PI9.GPIOParameters=GPIO_Speed
PI9.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PI9.Mode=RGB666
PI9.Signal=LTDC_VSYNC
RCC.HSE_VALUE=25000000
RCC.SYSCLKFreq_VALUE=216000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=EEZ H25005 MCU board v0.3

File dcm220/CubeMX/EEZ DIB DCM220 r2B2.ioc (part):

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Mcu.Name=STM32F373C(8-B-C)Tx
Mcu.Package=LQFP48
Mcu.UserName=STM32F373C8Tx
PA0.GPIOParameters=GPIO_Label
PA0.GPIO_Label=TEMP\#1
PA0.Mode=IN0
PA0.Signal=ADC1_IN0
PA1.GPIOParameters=GPIO_Label
PA1.GPIO_Label=CC_LED\#2
PA1.Signal=GPIO_Output
PA10.GPIOParameters=GPIO_Label
PA10.GPIO_Label=DIB_MOSI
PA10.Mode=Full_Duplex_Slave
PA10.Signal=SPI2_MOSI
PA11.GPIOParameters=GPIO_Label
PA11.GPIO_Label=DIB_NSS
PA11.Mode=NSS_Signal_Hard_Input
PA11.Signal=SPI2_NSS
PA12.GPIOParameters=GPIO_Label
PA12.GPIO_Label=DIB_IRQ
PA12.Signal=GPIO_Output
PA13.Mode=Trace_Asynchronous_SW
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Trace_Asynchronous_SW
PA14.Signal=SYS_JTCK-SWCLK
PA2.Mode=Asynchronous
PA2.Signal=USART2_TX
PA3.Mode=Asynchronous
PA3.Signal=USART2_RX
PA4.GPIOParameters=GPIO_Label
PA4.GPIO_Label=DAC_CS
PA4.Signal=GPIO_Output
PA5.GPIOParameters=GPIO_Label
PA5.GPIO_Label=DAC_SCLK
PA5.Mode=Simplex_Bidirectional_Master
PA5.Signal=SPI1_SCK
PA6.GPIOParameters=GPIO_Label
PA6.GPIO_Label=TEMP\#2
PA6.Mode=IN6
PA6.Signal=ADC1_IN6
PA8.GPIOParameters=GPIO_Label
PA8.GPIO_Label=DIB_SCLK
PA8.Mode=Full_Duplex_Slave
PA8.Signal=SPI2_SCK
PA9.GPIOParameters=GPIO_Label
PA9.GPIO_Label=DIB_MISO
PA9.Mode=Full_Duplex_Slave
PA9.Signal=SPI2_MISO
PB0.GPIOParameters=GPIO_Label
PB0.GPIO_Label=U_MON\#1
PB0.Mode=IN6-Single-Ended zero reference
PB0.Signal=SDADC1_AIN6P
PB1.GPIOParameters=GPIO_Label
PB1.GPIO_Label=I_MON\#1
PB1.Mode=IN5-Single-Ended zero reference
PB1.Signal=SDADC1_AIN5P
PB2.GPIOParameters=GPIO_Label
PB2.GPIO_Label=U_MON\#2
PB2.Mode=IN4-Single-Ended zero reference
PB2.Signal=SDADC1_AIN4P
PB3.Mode=Trace_Asynchronous_SW
PB3.Signal=SYS_JTDO-TRACESWO
PB4.GPIOParameters=GPIO_PuPd,GPIO_Label
PB4.GPIO_Label=PWRGOOD
PB4.GPIO_PuPd=GPIO_PULLUP
PB4.Signal=GPIO_Input
PB5.GPIOParameters=GPIO_Label
PB5.GPIO_Label=OE\#1
PB5.Signal=GPIO_Output
PB6.GPIOParameters=GPIO_Label
PB6.GPIO_Label=OE\#2
PB6.Signal=GPIO_Output
PB8.GPIOParameters=GPIO_Label
PB8.GPIO_Label=Reserved (CV\#2)
PB8.Signal=GPIO_Input
PB9.GPIOParameters=GPIO_Label
PB9.GPIO_Label=Reserved (CV\#1)
PB9.Signal=GPIO_Input
PC13.GPIOParameters=GPIO_Label
PC13.GPIO_Label=CC_LED\#1
PC13.Signal=GPIO_Output
PC14-OSC32_IN.GPIOParameters=GPIO_Label,GPIO_ModeDefaultEXTI
PC14-OSC32_IN.GPIO_Label=CC\#1
PC14-OSC32_IN.GPIO_ModeDefaultEXTI=GPIO_MODE_IT_RISING_FALLING
PC14-OSC32_IN.Signal=GPXTI14
PC15-OSC32_OUT.GPIOParameters=GPIO_Label,GPIO_ModeDefaultEXTI
PC15-OSC32_OUT.GPIO_Label=CC\#2
PC15-OSC32_OUT.GPIO_ModeDefaultEXTI=GPIO_MODE_IT_RISING_FALLING
PC15-OSC32_OUT.Signal=GPXTI15
PE8.GPIOParameters=GPIO_Label
PE8.GPIO_Label=I_MON\#2
PE8.Mode=IN8-Single-Ended zero reference
PE8.Signal=SDADC1_AIN8P
PF0-OSC_IN.Mode=HSE-External-Oscillator
PF0-OSC_IN.Signal=RCC_OSC_IN
PF1-OSC_OUT.Mode=HSE-External-Oscillator
PF1-OSC_OUT.Signal=RCC_OSC_OUT
PF6.GPIOParameters=GPIO_Label
PF6.GPIO_Label=DAC_MOSI
PF6.Mode=Simplex_Bidirectional_Master
PF6.Signal=SPI1_MOSI
PF7.GPIOParameters=GPIO_Label
PF7.GPIO_Label=DIB_SYNC
PF7.Signal=GPXTI7
RCC.HSEPLLFreq_Value=8000000
RCC.HSE_VALUE=16000000
RCC.SYSCLKFreq_VALUE=72000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

File dcm220/CubeMX/EEZ DIB DCM220 r2B4.ioc (part):

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Mcu.Name=STM32F373C(8-B-C)Tx
Mcu.Package=LQFP48
Mcu.UserName=STM32F373C8Tx
PA0.GPIOParameters=GPIO_Label
PA0.GPIO_Label=TEMP\#1
PA0.Mode=IN0
PA0.Signal=ADC1_IN0
PA1.GPIOParameters=GPIO_Label
PA1.GPIO_Label=CC_LED\#2
PA1.Signal=GPIO_Output
PA10.GPIOParameters=GPIO_Label
PA10.GPIO_Label=DIB_MOSI
PA10.Mode=Full_Duplex_Slave
PA10.Signal=SPI2_MOSI
PA11.GPIOParameters=GPIO_Label
PA11.GPIO_Label=DIB_NSS
PA11.Mode=NSS_Signal_Hard_Input
PA11.Signal=SPI2_NSS
PA12.GPIOParameters=GPIO_Label
PA12.GPIO_Label=DIB_IRQ
PA12.Signal=GPIO_Output
PA13.Mode=Trace_Asynchronous_SW
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Trace_Asynchronous_SW
PA14.Signal=SYS_JTCK-SWCLK
PA2.Mode=Asynchronous
PA2.Signal=USART2_TX
PA3.Mode=Asynchronous
PA3.Signal=USART2_RX
PA4.GPIOParameters=GPIO_Label
PA4.GPIO_Label=TEMP\#2
PA4.Mode=IN4
PA4.Signal=ADC1_IN4
PA5.GPIOParameters=GPIO_Label
PA5.GPIO_Label=U_SET\#2
PA5.Signal=COMP_DAC12_group
PA6.GPIOParameters=GPIO_Label
PA6.GPIO_Label=U_SET\#1
PA6.Signal=COMP_DAC21_group
PA8.GPIOParameters=GPIO_Label
PA8.GPIO_Label=DIB_SCLK
PA8.Mode=Full_Duplex_Slave
PA8.Signal=SPI2_SCK
PA9.GPIOParameters=GPIO_Label
PA9.GPIO_Label=DIB_MISO
PA9.Mode=Full_Duplex_Slave
PA9.Signal=SPI2_MISO
PB0.GPIOParameters=GPIO_Label
PB0.GPIO_Label=U_MON\#1
PB0.Mode=IN6-Single-Ended zero reference
PB0.Signal=SDADC1_AIN6P
PB1.GPIOParameters=GPIO_Label
PB1.GPIO_Label=I_MON\#1
PB1.Mode=IN5-Single-Ended zero reference
PB1.Signal=SDADC1_AIN5P
PB2.GPIOParameters=GPIO_Label
PB2.GPIO_Label=U_MON\#2
PB2.Mode=IN4-Single-Ended zero reference
PB2.Signal=SDADC1_AIN4P
PB3.Mode=Trace_Asynchronous_SW
PB3.Signal=SYS_JTDO-TRACESWO
PB4.GPIOParameters=GPIO_PuPd,GPIO_Label
PB4.GPIO_Label=PWRGOOD
PB4.GPIO_PuPd=GPIO_PULLUP
PB4.Signal=GPIO_Input
PB5.GPIOParameters=GPIO_Label
PB5.GPIO_Label=OE\#1
PB5.Signal=GPIO_Output
PB6.GPIOParameters=GPIO_Label
PB6.GPIO_Label=OE\#2
PB6.Signal=GPIO_Output
PB8.GPIOParameters=GPIO_Label
PB8.GPIO_Label=I_SET\#1
PB8.Signal=S_TIM16_CH1
PB9.GPIOParameters=GPIO_Label
PB9.GPIO_Label=I_SET\#2
PB9.Signal=S_TIM17_CH1
PC13.GPIOParameters=GPIO_Label
PC13.GPIO_Label=CC_LED\#1
PC13.Signal=GPIO_Output
PC14-OSC32_IN.GPIOParameters=GPIO_Label,GPIO_ModeDefaultEXTI
PC14-OSC32_IN.GPIO_Label=CC\#1
PC14-OSC32_IN.GPIO_ModeDefaultEXTI=GPIO_MODE_IT_RISING_FALLING
PC14-OSC32_IN.Signal=GPXTI14
PC15-OSC32_OUT.GPIOParameters=GPIO_Label,GPIO_ModeDefaultEXTI
PC15-OSC32_OUT.GPIO_Label=CC\#2
PC15-OSC32_OUT.GPIO_ModeDefaultEXTI=GPIO_MODE_IT_RISING_FALLING
PC15-OSC32_OUT.Signal=GPXTI15
PE8.GPIOParameters=GPIO_Label
PE8.GPIO_Label=I_MON\#2
PE8.Mode=IN8-Single-Ended zero reference
PE8.Signal=SDADC1_AIN8P
PF0-OSC_IN.Mode=HSE-External-Oscillator
PF0-OSC_IN.Signal=RCC_OSC_IN
PF1-OSC_OUT.Mode=HSE-External-Oscillator
PF1-OSC_OUT.Signal=RCC_OSC_OUT
PF7.GPIOParameters=GPIO_Label
PF7.GPIO_Label=DIB_SYNC
PF7.Signal=GPXTI7
RCC.HSEPLLFreq_Value=8000000
RCC.HSE_VALUE=16000000
RCC.SYSCLKFreq_VALUE=72000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

## Commit log (part)

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2018-08-29 Fixed Airwire in Eagle
    Fixed some existing Airwires in de Eagle Board
2018-08-29 Fixed Wire Stubs
    Fixed some Wire Stubs in the Eagle Design
2018-08-29 Converted Eagle Project to KiCad
    I importet the Eagle files to KiCad, so everybody can join and work on the pcb design with free open source software.
2018-08-29 Rename of the sheets
    Fixed the nameing of the sheets from the import into KiCad
2018-09-06 first version of AUX PS board
2018-09-07 mcu board BOM
2018-09-07 aux-ps BOM update, PE terminals added
2018-09-08 minor changes in BOMs
2018-09-08 changed AC capacitors to X2 class
2018-09-08 Kicad-ised schematic, fixed import errors
    Basic stuff like pin functions not assigned, and moving to heirarchial labels instead of global,
2018-09-08 Generated Netlist
    The netlist allows verification between SCH and PCB in kicad, so important for any newcomers who may try and use it.
2018-09-08 Generated Netlist File
    The netlist is an important file for linking SCH and PCB in kicad, it should be included to make it easy for newcomers,
2018-09-08 PCB Trace Matching to RAM
2018-09-09 Updating Kicad Files to r1B2
    Some component Values and connections had changed since r1B1 when kicad file was last converted, brought sch and pcb up to current eagle file.
2018-09-09 Left PE Ground trace dangling on USB connector
    Connected PE Trace, and 5V to L1,
2018-09-09 Refill Zones...
2018-09-12 mcu board prototype picture
2018-09-12 aux-ps SW1 adjustment
2018-09-14 SW2 changed
2018-09-14 mcu board C3 relocated
2018-09-15 Updating Kicad Files To Reflect Latest Commits
2018-09-25 .ioc changes for TFT, USB and SDRAM
2018-09-26 .ioc changes for ETH (25 MHz master clock)
2018-10-05 r1B2 changes
2018-10-06 PS AUX updated values for R30, C23
2018-10-06 PS AUX parts image updated
2018-10-18 MCU fixes: #10, #13, #15, #16, #17, #18
2018-11-05 #23, #24
2018-12-14 readme.md update
2018-12-30 first commit of DCP505 power board
2018-12-30 readme.md link fix
2018-12-30 small fixes
2018-12-31 PCB inductor added in schematics
2018-12-31 small PCB optimizations
2019-01-01 first bp3c commit
2019-01-02 SW1 position adjustment
2019-01-02 BP3C module addressing fix
2019-01-03 MCU JP4 added
2019-01-03 DCP505: replaced temperature sensor (IC7)
2019-01-03 fix PCB inductor dimensions
2019-01-03 removed hole on THT MOSFETs packages
2019-01-07 parts values and types corrections
2019-01-21 #26, #28, #29
2019-01-23 DCP505 fault indication fix
2019-01-24 MCU board minor changes
2019-01-24 AUX PS C2 moved away on the PCB from X1
2019-01-26 board pictures updated
2019-01-27 .ioc file for MCU r1B2
2019-02-02 enclosure fan holes corrected
2019-02-02 enclosure silkscreens
2019-02-02 module panel template
2019-02-07 #30, #31, #32
2019-02-07 enclosure holes fix for AUX PS
2019-02-07 pullup on fan controller SHDN pin, enclosure silkscreens updated
2019-03-09 temp. sensor C9 added
2019-03-16 X3 changed to vertical
2019-03-27 PE to Gnd caps added
2019-04-14 DCP405 module first commit
2019-04-14 chassis silkscreens adjustments
2019-04-24 DCP405 BOM
2019-05-19 DCP405 BOM update, JP2 added
2019-05-19 DCP405 JP3, JP4 added
2019-05-27 improved routing related to #40
2019-06-02 BP3C minor fixes
2019-06-08 add buydisplay.com TFT into MCU BOM
2019-06-08 #37, jumper replaced with micro switch
2019-06-08 #37, micro switch moved left
2019-06-14 MCU board chages for #37, #42
2019-06-14 MCU board Vdd trace fixed
2019-06-16 #37, place for optional jumper added
2019-06-18 major reorganization, introduced new PS AUX and BP3C that covers #37, #41
2019-06-18 readme.md links fixed
2019-06-18 enclosure front panel and DCP405 heatsink changes
2019-06-19 first prototype picture added
2019-06-19 enclosure dimensions corrected in readme.md
2019-06-19 BP3C module connectors moved up 0.5mm
2019-06-26 readme.md fix
2019-06-26 DCM220 sch update
2019-06-29 #44, #45
2019-06-29 DCM220, C36 value update
2019-06-29 #44, #45 Eagle files
2019-07-01 MCU board BOM update
2019-07-01 AUX PS BOM update
2019-07-01 BP3C readme.md update
2019-07-02 MCU J1 update
2019-07-02 MCU optional I/O protection
2019-07-04 DCM220 R8 value fixed
2019-07-10 enclosure prototype image update
2019-07-10 TVS added on outputs
2019-07-10 MCU Gerbers update
2019-07-13 update TME connectors in BOMs
2019-07-13 AUX-PS PCB redesign
2019-07-13 AUX-PS readme.md update
2019-07-13 BP3C BOM update
2019-07-16 PCB test tabs added
2019-07-21 DCP405 r2B5
2019-07-21 DCM220 name on PCB fixed
2019-07-23 multiple BOMs update
2019-07-24 enlosure BOM update
2019-07-24 multiple PCB layout adjustments
2019-07-24 micro SD card added into MCU BOM
2019-07-24 display support drawings added
2019-08-02 DCP405 BOM update
2019-08-04 MCU BOM update
2019-08-08 enclosure rear panel update
2019-08-08 enclosure BOM update
2019-08-09 Fan LDO control fixed
2019-08-15 DCP405 r2B6 (w/o BOM)
2019-08-17 DCM220 front panel corrections
2019-08-26 DCP405 r2B6 BOM
2019-08-28 AUX PS PWM pullup added
2019-08-28 MCU user sw cap changed to white
2019-08-28 MCU r1B5 STM32 .ioc
2019-08-29 pullup on enc sw in .ioc
2019-08-30 DCP405 CC comp correction
2019-08-30 DCP405 reverse sense clean up
2019-09-03 MCU reset issue, encoder moved
2019-09-04 DCP405 BOM and front panel update
2019-09-04 DCM220 r2B2 .ioc file
2019-09-06 AUX-PS softstart pull-downs changed
2019-09-11 DCP405 readme.md update
2019-09-18 BP3C reset fix
2019-09-18 #48, replaced DAC with PWM
2019-09-18 module front panels update
2019-09-18 AUX-PS SW2 replaced with tactile switch
2019-09-19 prereg Rsense to R008
2019-09-21 DCM220 I_SET gain adjustment
2019-09-21 DCP405 CV, CC compensations adjustment
2019-09-21 MCU IC2 label added
2019-09-26 DCP405 OVP up-programming adjustment
2019-09-26 DCP405 OVP U_SET fixed
2019-10-02 BOM updates
2019-10-03 DCM220 IC2 bottom stop mask correction
2019-10-06 DCM220 r2B4
2019-10-06 DCP405 Q18 added to HW OVP
2019-10-08 DCM220 diff. opamps gain correction
2019-10-08 DCM220 eagle files
2019-10-11 DCM220 r2B4 .ioc update
2019-10-12 Enclosure BOM update (M3x8 countersink for AC inlet)
2019-10-12 Enclosure and AUX-PS BOM updates
2019-10-16 new enclosure picture
2019-10-27 DCM220 r2B5
2019-10-28 DCP405 OE slow down
2019-10-28 new AC/DC power modules mounting plate
2019-10-31 DCM220 PCB corrections
2019-11-06 BOMs update
2019-11-18 front panel Tx/Rx swap, BOM updates
2019-11-21 Gerbers unzipped for kitspace
2019-11-21 Adding kitspace.yaml
2019-11-22 Adding multy kitspace and 1 click BOMs
2019-11-22 first user manual draft, proofreading required!
2019-11-23 combinumerals font
2019-11-24 chapter 2 first read through
2019-11-24 R28 set to N.C.
2019-11-25 user manual firmware upgrade changed
2019-11-25 DCP405 Eagle files updated
2019-11-25 minor BOM changes
2019-11-26 chapters 3 and 4 read through & corrections
2019-11-30 Chapter 5 read through
2019-12-01 Accepted changes in user manual (1-5)
2019-12-02 a couple of very minor changes https://github.com/eez-open/modular-psu/pull/58#issuecomment-560120879 and https://github.com/eez-open/modular-psu/pull/55#issuecomment-560120683
2019-12-02 very few changes for chapter 6
2019-12-02 a couple of minor corrections
2019-12-02 a couple of minor changes
2019-12-02 very few changes for chapter 9
2019-12-04 user manual data logging chapter
2019-12-07 #53 (DCM220 r2B6)
2019-12-07 DCM220 r2B6 .ioc file
2019-12-07 DCM220 BOM update
2019-12-12 MCU r2B1 with Ethernet rotated
2019-12-13 MCU r2B1 with Ethernet and USB rotated
2019-12-14 DCP405 r2B8
2019-12-19 AUX PS PCB improvements, DCM220 ZD2, ZD4 correction
2019-12-20 DCP405 BOM corrections
2019-12-21 clean up Gerber files
2019-12-21 readme.md links
2019-12-21 unzip Gerbers for Kitspace
2019-12-22 DCP405 X2 BOM update
2019-12-23 Update 1-click-bom for dcm220
2020-01-04 DCP405, DCM220 new pictures
2020-01-04 DCM220 EEPROM mmoved, OSHWA UID added
2020-01-04 DCP405 EEPROM moved, OSHWA UID added
2020-01-05 DCP405 CC compensation correction, split BOMs
2020-01-06 DCP405 D17, ZD5 added
2020-01-07 move MCU kicad to previous designs
2020-01-11 #63, remove BOOT sw from AUX-PS
2020-01-13 DCP405 CC correction for DP
2020-01-13 add OSHWA ID on BP3C PCB
2020-01-13 DCP405 D17 set to N.C., DIB v1.0 update
2020-01-14 MCU PCB small correction
2020-01-14 new enclosure front and rear panel
2020-01-16 rear panel Ethernet holes correction
2020-01-21 MCU r2B4, battery holder moved to opposite side
2020-01-26 AUX-PS PCB layout update
2020-01-29 DCM220 OE pull-down added
2020-01-29 Centroid files added
2020-01-31 DCM220 HSE removed
2020-02-20 DCP405 OVP adjustment
2020-02-20 DCP405 centroid files update
2020-02-21 Updating BP3 1 click BOM
2020-02-21 Adding new DCM220 BOM
2020-02-21 Adding DCP405
2020-02-21 New BOM for MCU
2020-02-21 Removing dash - fix RS part
2020-02-21 shift by 1
2020-03-06 MCU BOM R28, R29 correction
2020-03-11 AUX-PS SW1 value fixed
2020-03-11 OSHW logo added
2020-03-20 MCU PCB inner layers extension name
2020-03-23 DCP405 swap LED1 and LED2 in BOM
2020-03-24 MCU SDcard PCB pads adjustment
2020-03-26 User manual draft v0.3
2020-03-29 User manual datetime settings update
2020-04-07 Small BOM fixes, first German user manual commit
2020-04-07 final proof of chapter 3
2020-04-07 user manual: channel trigger settings
2020-04-08 MCU part number updated in schematics
2020-04-08 final proof of ch4 system settings
2020-04-09 final proofread completed
2020-04-12 DCM220 BOM update (R45,R69)
2020-04-15 German user manual update
2020-04-17 minor changes to chapter 11
2020-04-17 ramp and delay editing
2020-04-17 User manual v1.0
2020-04-18 User manual links update
2020-04-18 User manual lower PDF resolution
2020-04-21 kit assembly instructions
2020-04-24 Suggested improvements to BB3 kit assembly instructions
2020-04-25 mcdanlj, dunkemhigh changes in kit assembly instructions
2020-04-26 update module pictures
2020-04-26 MCU readme.md update
2020-04-28 EEZ BB3 enclosure and bare PCBs assembly first commit
2020-04-28 Changing R45,R69 to 100K
2020-05-04 User manual firmware upgrade corrections
2020-05-05 DIB module templates
2020-05-09 calibration procedures - some small suggested improvements
2020-05-10 User manual v1.01
2020-05-22 BP3C description fixed
2020-05-26 DCP405 fuse rating changed
2020-06-02 MCU ZD1 value correction
2020-06-11 MCU .ioc version update
2020-06-12 DIB v1.1, BP3C r3B3
2020-06-12 wire harness doc
2020-06-12 BP3C new ZD1-ZD4 type
2020-06-12 DIB alternative IRQs added
2020-06-29 MCU readme update
2020-07-30 DCP405 and enclosure BOM update
2020-08-26 ULVO levels update for power modules
2020-08-26 web content folder
2020-08-26 web content PDF file
2020-08-28 FB values updated for DCP405 and DCM220
2020-09-09 MCU I2C pull-up update
2020-09-09 MCU IC6 model type update
2020-09-25 added cooling fan alternative
2020-11-01 liberapay badge
2020-11-01 liberapay badgefix
2020-11-06 combined LRS/EPP Mean Well support
2020-11-08 BP3C X5,X6,X7 package desc. update
2020-12-06 enclosure picture update
2020-12-25 enclosure bottom plate corrections
2020-12-25 enclosure front panel corrections
2020-12-25 enclosure bottom plate corrections (2)
2020-12-25 enclosure top plate corrections
2020-12-25 enclosure front panel corrections (3)
2020-12-25 enclosure display support corrections
2020-12-28 DIB v1.2 specification (ADIB added)
2021-01-31 MCU and DCP BOM small changes
2021-02-01 BP3C bottom layer cleanup
2021-02-12 User manual update
2021-02-15 New AUX-PS, #70, #83, #84
2021-02-15 New MCU, #70, #73, #75, #84, #85, #86, #90
2021-02-15 New DCP405, #81, #96
2021-02-16 Benutzerhandbuch v1.04 thanks to Jochen Hammer
2021-02-19 #97, User manual updates
2021-03-13 #103
2021-03-21 #105
2021-03-25 links fixed in README.md
2021-03-31 .ioc update, SPI speed adjustment
2021-04-01 User manual v1.05
2021-04-21 README.md updates
2021-06-27 PGND replaced with GND on few places
2021-09-23 New chapters in User manual
2021-09-23 Made relation of jumpers to PWM channel explicit.
2021-09-24 Add speaker alternative in BOM
2021-10-03 PCB layout for SMD/THT loudspeaker
2022-11-29 User manual 1.09
2023-02-16 Add readme paths in kitspace.yaml
2023-08-24 DCP405 r4 preliminary design
2023-08-24 DCP405 r4 EDA files
2023-08-24 4-layer cam file update
2023-08-25 Update Note 3.1. in DCP405 schematics
2024-01-02 AUX-PS module migration to KiCad
2024-01-03 BP3C and DIB module template migration to KiCad
2024-01-04 Eagle schematics pdf files

Notices in the files:
parts and their libraries:
EEZ_DIB: This work is licensed under the TAPR Open Hardware License.
